# Allegro board Edison_arduino_5_0826.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBUS: length 8.6
  TOP w0.203: J7.20 21.3,16.67 20.96,17.02
  TOP w0.3: Q10.2 103.02,19.59 ; Q10.3 103.02,18.64 ; CR1.2 v1(108.23,41.81)
  BOTTOM w0.3: v1(16.76,20.07) 16.83,20 TP18.1
  vias: v1(16.76,20.83) v1(114.45,16.66) v1(114.45,15.71)
VBUS_2: length 11.6
  TOP w0.3: U2.19 110.76,8.74 110.49,9.01 C9.2 R8.1
  TOP w0.33: 111.65,9.64 R8.1
  TOP w0.381: 111.65,9.64 114.11,9.64 115.22,8.53 115.22,6.41 116.41,5.22 117.49,5.24
VBUS_IN: length 5.9
  TOP w0.127: 108.74,20.09 108.12,20.09 R96.1 108.1,19.08
  TOP w0.381: J16.1 116.49,19.19 116.48,19.2 ; 113.18,18.58 CR8.2 ; CR8.2 113.98,19.2 ; CR8.2 112.38,19.2
  TOP w0.5: Q10.4 107.83,18.64 107.84,18.63
VBUS_OUT: length 3.9
  TOP w0.127: J6.1 C36.1 v1(111.03,44.22)
  TOP w0.25: U36.1 25.13,36.9 v1(24.92,37.11)
VIN: length 3.9
  PWR_GND w0.381: 74.6,59.16 J2A1.8 ; J2A1.8 73.63,60.12 ; J2A1.8 74.6,61.09 ; J2A1.8 75.57,60.12
  vias: v1(96.03,61.22) v1(96.05,60.35) v1(96.03,59.36) v1(96.05,58.46)
A0: length 55.7
  TOP w0.127: U15.A1 v1(62.5,40.76) ; J1A1.1 67.97,58.57 66.19,58.57 62.36,54.74 62.36,47.01 61.35,46 R52.2
  BOTTOM w0.127: J1A1.1 69.22,60.43 TP64.1 70.87,63.12 70.87,51.74 71.02,51.59 71.02,49.81 70.13,48.92 69.24,48.92 68.2,47.88 64.49,47.88 61.75,45.14 61.75,43.91 62.5,43.16 v1(62.5,40.76)
A1: length 55.2
  TOP w0.127: J1A1.2 61.72,54.86 61.72,47.18 61.29,46.75 R53.2 ; U13.A1 v1(64.75,40.75)
  BOTTOM w0.127: J1A1.2 66.67,60.43 TP65.1 67.35,65.44 69.73,65.44 71.42,63.74 71.42,49.71 70.26,48.54 69.47,48.54 68.12,47.19 65.76,47.19 63.98,45.42 63.98,43.84 64.75,43.07 v1(64.75,40.75)
A2: length 55.4
  TOP w0.127: U11.A1 v1(67,40.76) ; R54.2 61.03,56.72 J1A1.3
  BOTTOM w0.127: v1(67,40.76) 67,43.44 65.99,44.45 65.99,46 66.57,46.58 68.78,46.58 71.86,49.66 71.86,63.79 69.92,65.73 65.09,65.73 TP66.1 64.13,60.43 J1A1.3
A3: length 53.9
  TOP w0.127: U9.A1 v1(69.25,40.76) ; R55.2 60.49,52.52 60.49,58.71 J1A1.4
  BOTTOM w0.127: v1(69.25,40.76) 69.25,43.17 68.4,44.02 68.4,44.75 69.04,45.39 69.04,46 72.34,49.3 72.34,63.81 70.1,66.05 62.88,66.05 TP67.1 61.59,60.43 J1A1.4
A4: length 106.7
  TOP w0.127: J1A1.5 59.36,52.7 57.5,50.85 R56.2 ; U7.A1 v1(71.5,40.76) ; J2B1.9 98.98,19.69 88.39,30.28 88.39,34.42 87.38,35.43 78.36,35.43 76.58,33.66 73.38,33.66 v1(72.75,34.29)
  BOTTOM w0.127: v1(72.75,34.29) 72.52,34.52 72.52,38.71 71.5,39.73 v1(71.5,40.76) 71.5,43.38 70.66,44.22 70.66,44.65 72.87,46.86 72.87,63.76 70.3,66.34 60.62,66.34 TP68.1 59.05,60.43 J1A1.5
A5: length 109.3
  TOP w0.127: J2B1.10 101.52,17.78 88.77,30.53 88.77,34.57 87.53,35.81 76.53,35.81 v1(75.01,34.29) ; R57.2 56.75,51.16 58.42,52.83 58.42,58.52 J1A1.6 ; U5.A1 v1(73.75,40.76)
  BOTTOM w0.127: v1(75.01,34.29) 75.01,38.22 73.75,39.48 v1(73.75,40.76) 73.75,43.17 72.97,43.94 72.97,44.75 74.09,45.87 74.09,56.67 73.36,57.4 73.36,63.74 70.43,66.67 58.41,66.67 TP69.1 56.52,60.43 J1A1.6
AIN0: length 50
  TOP w0.127: R74.2 100.53,34.47 100.71,34.29 100.71,30.71 99,29 90.93,29 89.15,30.77 89.15,34.67 87.63,36.2 64.9,36.2 63.63,37.47 63.63,38.62 U15.C2
AIN1: length 43.6
  TOP w0.127: R75.2 99.5,30.75 98,29.25 91.25,29.25 89.64,30.87 89.64,34.83 87.88,36.58 66.55,36.58 65.79,37.34 65.79,38.71 U13.C2
AIN2: length 39.4
  TOP w0.127: U11.C2 68.07,38.68 68.07,37.47 68.58,36.96 88,36.96 90.14,34.82 90.14,31.07 91.46,29.75 97.25,29.75 98,30.5 R76.2
AIN3: length 35
  TOP w0.127: U9.C2 70.23,38.77 70.23,37.72 70.59,37.37 88.3,37.37 90.64,35.03 90.64,31.28 91.66,30.25 96,30.25 96.5,30.75 R77.2
AIN4: length 30.2
  TOP w0.127: R78.2 95,31.25 94.5,30.75 91.87,30.75 91.14,31.49 91.14,35.24 88.65,37.72 73.03,37.72 72.52,38.23 72.52,38.73 U7.C2
AIN5: length 25.4
  TOP w0.127: U5.C2 75.5,39.25 76.27,38.48 88.6,38.48 91.64,35.44 91.64,31.94 92.32,31.25 93.25,31.25 93.5,31.5 R79.2
AREF: length 67.7
  BOTTOM w0.127: J2B1.8 96.44,15.42 105.03,24 105.03,28.73 105.92,29.62 107.85,29.62 110.28,32.05 110.28,35.36 105.6,40.03 104.49,40.03 102.84,41.68 97.94,41.68 97.82,41.56 93.88,41.56 92.61,40.29 91.47,40.29 91.2,40.55 91.2,44.67 89.82,46.05 89.82,51.15 J8.3
DIG0: length 37.8
  TOP w0.127: R64.2 76.84,26.75 v1(76.84,26.75) ; U33.C2 56.82,15.1 v1(57.09,14.83) 56.82,14.56 56.82,11.86 J1B1.1
  BOTTOM w0.127: TP70.1 56.77,11.81 J1B1.1 ; v1(57.09,14.83) 57.79,15.53 57.79,17.48 59.98,19.69 65.2,19.69 65.3,19.59 72.96,19.59 74.7,21.33 74.7,24.62 v1(76.84,26.75)
DIG1: length 34.8
  TOP w0.127: U31.C2 59.36,15.1 v1(59.63,14.83) 59.36,14.56 59.36,11.86 J1B1.2 ; R65.2 v1(77.35,26)
  BOTTOM w0.127: TP71.1 59.31,11.81 J1B1.2 ; v1(59.63,14.83) 60.33,15.53 60.33,17.43 62.2,19.3 73.22,19.3 75.06,21.14 75.06,24.38 76.67,26 v1(77.35,26)
DIG2: length 31.8
  TOP w0.127: J1B1.3 61.9,11.86 61.9,14.56 v1(62.17,14.83) 61.9,15.1 U29.C2 ; v1(76.84,25.25) 76.84,25.25 R66.2
  BOTTOM w0.127: TP72.1 61.85,11.81 J1B1.3 ; v1(76.84,25.25) 75.44,23.85 75.44,20.99 73.38,18.92 64.13,18.92 62.87,17.65 62.87,15.53 v1(62.17,14.83)
DIG3: length 29.1
  TOP w0.127: U27.C2 64.44,15.1 v1(64.71,14.83) 64.44,14.56 64.44,11.86 J1B1.4 ; R67.2 v1(77.35,24.5)
  BOTTOM w0.127: v1(77.35,24.5) 76.7,24.5 75.82,23.62 75.82,20.83 73.53,18.54 66.04,18.54 65.28,17.78 65.28,15.4 v1(64.71,14.83) ; J1B1.4 64.52,11.79 TP73.1
DIG4: length 26
  TOP w0.127: R68.2 76.84,23.75 v1(76.84,23.75) ; U24.C2 66.98,15.1 v1(67.25,14.83) 66.98,14.56 66.98,11.86 J1B1.5
  BOTTOM w0.127: v1(67.25,14.83) 67.94,15.53 67.94,17.27 68.83,18.16 74.3,18.16 76.84,20.7 v1(76.84,23.75) ; TP74.1 67.06,11.79 J1B1.5
DIG5: length 22.8
  TOP w0.127: R69.2 v1(77.35,23) ; U21.C2 69.52,15.1 v1(69.79,14.83) 69.52,14.56 69.52,11.86 J1B1.6
  BOTTOM w0.127: v1(69.79,14.83) 70.36,15.4 70.36,17.27 70.87,17.78 74.42,17.78 77.35,20.71 v1(77.35,23) ; TP75.1 69.6,11.79 J1B1.6
DIG6: length 9.4
  TOP w0.127: R70.2 72.07,15.54 U19.C2 72.06,11.86 J1B1.7
  BOTTOM w0.127: J1B1.7 72.01,11.81 TP76.1
DIG7: length 9.6
  TOP w0.127: J1B1.8 74.6,11.86 U32.C2 75.53,15.53 R71.2
  BOTTOM w0.127: TP77.1 74.55,11.81 J1B1.8
DIG8: length 16.4
  TOP w0.127: U30.C2 78.66,15.1 v1(78.93,14.83) 78.66,14.56 78.66,11.86 J2B1.1 ; R58.2 82.5,20.52 v1(82.3,20.32)
  BOTTOM w0.127: v1(78.93,14.83) 79.63,15.53 79.63,17.65 v1(82.3,20.32) ; J2B1.1 78.61,11.81 TP78.1
DIG9: length 15.7
  TOP w0.127: U28.C2 81.2,15.1 v1(81.47,14.83) 81.2,14.56 81.2,11.86 J2B1.2 ; R59.2 v1(83.25,20.35)
  BOTTOM w0.127: v1(81.47,14.83) 82.04,15.4 82.04,19.14 v1(83.25,20.35) ; TP79.1 81.28,11.79 J2B1.2
DIG10: length 15.4
  TOP w0.127: v1(84.2,20.32) 84,20.52 R60.2 ; J2B1.3 83.74,11.86 83.74,14.56 v1(84.01,14.83) 83.74,15.1 U26.C2
  BOTTOM w0.127: TP80.1 83.82,11.79 J2B1.3 ; v1(84.01,14.83) 84.58,15.4 84.58,19.94 v1(84.2,20.32)
DIG11: length 66.4
  TOP w0.127: R61.2 86.86,23.25 v1(87,23.11) 87,22.35 84.48,19.84 81.69,19.84 79.02,22.51 76.55,22.51 74.42,24.64 74.42,28.15 72.7,29.87 62.64,29.87 59.97,32.54 58.57,32.54 57.59,33.53 55.35,33.53 J4.4 ; U23.C2 86.28,15.1 v1(86.55,14.83) 86.28,14.56 86.28,11.86 J2B1.4
  BOTTOM w0.127: v1(86.55,14.83) 86.55,15.56 87.15,16.16 87.15,17.05 88.42,18.32 88.42,18.57 88.8,18.95 90.58,18.95 90.96,19.33 90.96,21.24 89.08,23.11 v1(87,23.11) ; J2B1.4 86.23,11.81 TP81.1
DIG12: length 65.1
  TOP w0.127: J2B1.5 88.82,11.86 88.82,14.56 v1(89.09,14.83) 88.82,15.1 U20.C2 ; R62.2 v1(86.9,24) 87.12,24 87.63,23.5 87.63,22.61 84.61,19.59 81.56,19.59 78.89,22.25 76.17,22.25 73.91,24.51 73.91,27.81 72.14,29.59 62.54,29.59 59.95,32.18 J4.1
  BOTTOM w0.127: v1(89.09,14.83) 89.09,15.43 89.94,16.28 89.94,17.43 90.32,17.81 90.58,17.81 90.96,18.19 90.96,18.82 92.36,20.22 92.36,21.24 89.59,24 v1(86.9,24) ; TP82.1 88.77,11.81 J2B1.5
DIG13: length 67.6
  TOP w0.127: J2B1.6 91.36,11.86 91.36,14.56 v1(91.63,14.83) 91.36,15.1 U18.C2 ; R63.2 86.73,24.75 v1(86.87,24.89) 87.25,24.89 88.01,24.13 88.01,22.61 84.74,19.33 81.43,19.33 78.77,22 75.79,22 73.41,24.38 73.41,27.18 71.35,29.24 62.18,29.24 v1(59.8,31.61)
  BOTTOM w0.127: v1(59.8,31.61) J4.3 ; TP83.1 91.31,11.81 J2B1.6 ; v1(91.63,14.83) 91.63,15.94 92.74,17.05 92.74,21.74 89.69,24.79 86.97,24.79 v1(86.87,24.89)
DIG13_1P8: length 65.8
  TOP w0.127: v1(90.07,15.27) 90.33,15.53 U18.C1 ; R87.1 45.12,25.17 46.89,23.4 54.89,23.4 60.48,28.98 70.89,28.98 73.05,26.82 73.05,24.16 75.47,21.74 78.64,21.74 81.31,19.08 86.64,19.08 87.66,18.06 91.09,18.06 v1(91.47,18.44) 91.46,18.45 U43.A1
  TOP w0.2: Q9.1 R87.1
  BOTTOM w0.127: v1(90.07,15.27) 90.32,15.27 90.96,15.9 90.96,17.81 91.47,18.32 v1(91.47,18.44)
FAULT: length 39.9
  TOP w0.127: v1(20.5,8) 20.02,8.48 20.02,9.34 20.14,9.47 R36.1 20.77,9.47 21.3,10 J7.19 ; U36.3 25.82,32.93 v1(22.48,29.59)
  BOTTOM w0.127: v1(22.48,29.59) 14.82,21.94 14.82,17.9 15.94,16.79 15.94,13.94 20.5,9.38 20.5,8 v1(20.5,8) TP19.1
FW_RCVR: length 127
  TOP w0.127: v1(8.41,65.81) 8.41,66.82 SW1UI3.1 ; J7.69 31.3,10.23 32.51,9.02 32.98,9.02 v1(34,8)
  BOTTOM w0.127: v1(8.41,65.81) 8.41,61.75 9.81,60.35 9.81,57.3 7.9,55.4 5.36,55.4 3.84,53.88 3.84,31.52 4.73,30.63 26.95,30.63 27.97,29.62 27.97,28.48 26.32,26.82 22,26.82 16.04,20.87 16.04,19.45 17.27,18.22 17.27,14.57 18.59,13.25 30.88,13.25 33.75,10.38 36.29,10.38 36.86,10.95 38.13,10.95 38.63,10.44 38.63,7.65 38.38,7.39 36.6,7.39 36,8 v1(34,8) TP63.1
GP12_PWM0: length 43.7
  TOP w0.127: v1(32.64,9.78) 33.53,9.78 33.73,9.98 34.72,9.98 35.43,9.27 38.61,9.27 42.45,13.11 42.45,14.25 43.51,15.32 44.53,15.32 45.16,15.95 45.16,18.08 J12.2 ; J7.35 24.5,4 v1(23.5,3)
  BOTTOM w0.127: TP34.1 v1(23.5,3) 24.26,3.76 24.26,5.46 25.02,6.22 25.53,6.22 25.78,6.48 25.78,8 27.56,9.78 v1(32.64,9.78)
GP13_PWM1: length 36.8
  TOP w0.127: v1(23.5,5.5) 24,6 24,8 24.1,8.1 J7.33 ; v1(36.73,9.81) 38.63,9.81 42.06,13.24 42.06,14.51 43.79,16.23 J11.2
  BOTTOM w0.127: v1(36.73,9.81) 36.48,10.06 33.7,10.06 32.46,11.3 25.27,11.3 24.38,10.41 24.38,6.1 23.79,5.5 v1(23.5,5.5) TP32.1
GP14: length 77.4
  TOP w0.127: v1(72.25,44.45) 72,44.21 U6.C1 ; v1(26,19) 26,17.31 26.48,16.83 26.48,15.81 26.9,15.39 J7.48
  BOTTOM w0.127: v1(26,19) TP41.1 26,20.16 25.17,20.98 25.17,23.52 25.94,24.28 32.79,24.28 33.55,23.52 33.55,22.51 34.19,21.87 41.43,21.87 44.1,24.54 56.29,24.54 61.24,29.49 68.23,29.49 71.91,33.17 73.18,33.17 73.6,33.59 73.6,38.93 72.25,40.28 72.25,41.15 72.07,41.33 72.07,44.28 v1(72.25,44.45)
GP15: length 79.2
  TOP w0.127: v1(27.55,46.85) 27.55,39.5 29.75,37.3 29.75,30.15 28.65,29.05 28.65,25.65 25.25,22.25 25.25,15.35 25.7,14.9 J7.42 ; R122.1 63.65,47.85 63.6,47.85 60.55,44.8 59.8,44.8 59.8,44.7 59.7,44.7 v1(59.7,44.78) ; v1(54.3,44.4) 52.55,44.4 v1(52.25,44.7) 52.95,44.7 54.25,46 U17.22
  BOTTOM w0.127: v1(27.55,46.85) 31.45,46.85 32.25,46.05 TP88.1 50.9,46.05 v1(52.25,44.7) ; v1(54.3,44.4) 54.35,44.4 54.75,44.8 59.8,44.8 59.8,44.7 59.7,44.7 v1(59.7,44.78)
GP19: length 171.4
  TOP w0.127: v1(85.47,34.93) 85.47,34.8 85.47,34.8 85.47,33.02 85.72,32.77 87.5,32.77 88.01,32.26 88.01,30.15 95.4,22.76 95.4,8.16 88.93,1.68 27.82,1.68 v1(26.5,3) 26.06,3.44 26.06,8.62 25.7,8.97 J7.41 ; v1(69.85,27.94) 69.47,27.56 68.96,27.56 68.75,27.35 U34.19 ; R44.1 64.83,51.75 v1(64.9,51.82) 64.9,51.72 65.11,51.5 U16.19 ; v1(75.56,54.61) v1(69.85,54.61)
  BOTTOM w0.127: v1(75.56,54.61) 75.56,53.59 83.67,45.49 83.67,42.14 85.47,40.34 v1(85.47,34.93) 84.71,34.16 81.28,34.16 77.62,30.51 72.42,30.51 v1(69.85,27.94) ; v1(64.9,51.82) 65.66,51.82 68.45,54.61 v1(69.85,54.61) ; TP37.1 v1(26.5,3)
GP20: length 169.8
  TOP w0.127: v1(68.71,27.94) 68.25,27.48 U34.20 ; U16.20 64.97,51 v1(64.9,50.93) 64.82,51 R43.1 ; v1(80.97,34.93) 80.97,34.8 80.97,34.8 80.97,32.7 81.28,32.39 87.12,32.39 87.5,32 87.5,30.03 88.29,29.24 88.42,29.24 88.8,28.86 88.8,28.73 92.99,24.54 92.99,20.86 94.52,19.33 94.52,15.01 95.02,14.51 95.02,8.54 88.55,2.06 28.17,2.06 26.5,3.73 v1(26.5,5.5) 27,6 27,8.31 26.1,9.21 J7.43 ; v1(69.85,53.34) 70.74,54.23 74.04,54.23 v1(74.93,53.34)
  BOTTOM w0.127: v1(74.93,53.34) 83.19,45.09 83.19,37.14 v1(80.97,34.93) 80.97,34.63 77.36,31.02 71.78,31.02 v1(68.71,27.94) ; v1(69.85,53.34) 69.44,53.75 68.35,53.75 65.53,50.93 v1(64.9,50.93) ; TP38.1 v1(26.5,5.5)
GP27: length 121.9
  TOP w0.127: Q3.2 77.5,51.03 R39.1 76.86,53.64 76.86,56.08 71.35,61.59 53.63,61.59 50.91,58.88 50.91,58.11 v1(51.36,57.66) ; v1(28,3) 27.43,3.57 27.43,8.51 26.5,9.44 J7.45 ; v1(39.88,25.91) 38.48,24.51 v1(38.48,11.94)
  BOTTOM w0.127: v1(38.48,11.94) 38.89,11.53 38.89,7.27 36.7,5.08 35.31,5.08 34.42,5.97 29.21,5.97 28.7,5.46 28.7,3.7 v1(28,3) TP40.1 ; v1(39.88,25.91) 41.05,27.08 45.44,27.08 51.56,33.2 51.56,38.19 53.85,40.48 53.85,40.6 53.85,40.6 53.85,42.8 53.95,42.9 53.95,43.5 53.85,43.6 53.85,44.2 53.85,44.2 53.85,44.25 51.56,46.54 51.56,51.44 50.4,52.6 50.4,56.7 v1(51.36,57.66)
GP28: length 113.1
  TOP w0.127: v1(28,8) 28,8.83 26.9,9.93 J7.47 ; Q4.2 72.5,51.03 R40.1 72.5,53.32 72.77,53.59 73.91,53.59 74.8,52.7 75.51,52.7 76.2,53.39 76.2,55.93 71.04,61.09 53.99,61.09 v1(51.52,58.62) ; v1(37.85,10.31) 37.85,24.89 v1(38.86,25.91)
  BOTTOM w0.127: v1(51.52,58.62) 51.12,58.62 49.9,57.4 49.9,52.6 51.05,51.45 51.05,46.6 53.56,44.09 53.56,43.49 53.65,43.4 53.65,43 53.56,42.91 53.56,40.72 51.05,38.22 51.05,33.48 45.01,27.43 40.39,27.43 v1(38.86,25.91) ; TP42.1 v1(28,8) 29.04,9.04 37.24,9.04 37.85,9.65 v1(37.85,10.31)
GP40: length 80.4
  TOP w0.127: J7.52 27.7,16.3 v1(27.5,16.5) ; U43.B2 90.45,19.72 v1(90.2,19.46)
  BOTTOM w0.127: v1(90.2,19.46) 88.04,19.46 87.53,18.95 87.15,18.95 83.34,22.76 81.69,22.76 77.24,27.21 76.61,27.21 74.45,25.05 74.45,21.62 72.67,19.84 65.43,19.84 64.92,20.35 59.84,20.35 56.67,23.52 45.11,23.52 38.76,17.17 33.3,17.17 32.03,15.9 28.1,15.9 v1(27.5,16.5) TP44.1
GP41: length 106.3
  TOP w0.127: U40.B2 107.47,32.15 108.48,31.14 108.48,27.33 105.44,24.28 96.29,24.28 95.28,25.3 v1(95.28,27.84) ; J7.54 28.1,18.4 v1(27.5,19)
  BOTTOM w0.127: v1(95.28,27.84) 87.91,27.84 85.88,25.81 83.97,25.81 82.83,26.95 80.93,26.95 80.04,27.84 76.48,27.84 73.81,25.17 73.81,22.12 73.05,21.36 60.86,21.36 58.19,24.03 44.6,24.03 41.22,20.65 27.76,20.65 27.5,20.39 TP46.1 v1(27.5,19)
GP42: length 85.6
  TOP w0.127: v1(26,21.5) 26.8,20.7 26.8,16 27.3,15.5 J7.50 ; U42.B2 88.04,19.72 87.78,19.46 v1(87.28,19.46)
  BOTTOM w0.127: TP43.1 v1(26,21.5) 26.57,20.93 26.57,18.69 27.08,18.19 39.4,18.19 44.98,23.78 57.56,23.78 60.48,20.86 73.31,20.86 74.2,21.74 74.2,25.17 76.48,27.46 77.37,27.46 81.81,23.01 83.72,23.01 v1(87.28,19.46)
GP43: length 109.1
  TOP w0.127: v1(107.6,35.33) 107.47,35.2 U41.B2 ; v1(29,19) 28.5,18.5 J7.56
  BOTTOM w0.127: TP48.1 v1(29,19) 28.91,19 28.35,18.44 27.33,18.44 26.93,18.85 26.93,20.63 27.33,21.03 41.1,21.03 44.35,24.28 58.7,24.28 61.24,21.74 72.67,21.74 73.31,22.38 73.31,25.05 80.93,32.67 89.31,32.67 91.72,35.08 91.72,39.14 92.1,39.52 97.44,39.52 97.69,39.27 101.37,39.27 102.26,38.38 106.67,38.38 108.21,36.84 108.21,35.94 v1(107.6,35.33)
GP44: length 71.8
  TOP w0.127: J7.24 22.1,18.92 v1(21.84,19.18) ; v1(63.25,44.45) 63,44.21 U14.C1
  BOTTOM w0.127: v1(21.84,19.18) 21.5,19.52 TP22.1 21.46,20.04 21.46,21.21 20.9,21.77 20.9,23.24 24.23,26.57 36.73,26.57 38.38,24.92 42.95,24.92 44.68,26.64 45.97,26.64 50.19,30.86 62.99,30.86 64.6,32.47 64.6,38.93 63.25,40.28 63.25,41.15 63.07,41.33 63.07,44.28 v1(63.25,44.45)
GP45: length 73.7
  TOP w0.127: v1(65.5,44.45) 65.25,44.21 U12.C1 ; J7.26 22.5,20.5 22.48,20.52 v1(22.48,22.48)
  BOTTOM w0.127: v1(65.5,44.45) 65.32,44.28 65.32,41.33 65.5,41.15 65.5,40.28 66.85,38.93 66.85,32.77 64.56,30.48 51.56,30.48 46.38,25.3 43.72,25.3 42.93,24.51 35.49,24.51 33.81,26.19 24.54,26.19 21.5,23.15 TP24.1 22.46,22.5 v1(22.48,22.48)
GP46: length 74.5
  TOP w0.127: U10.C1 67.5,44.21 v1(67.75,44.45) ; v1(23,16.5) 22.9,16.4 J7.28
  BOTTOM w0.127: v1(67.75,44.45) 67.57,44.28 67.57,41.33 67.75,41.15 67.75,40.28 69.1,38.93 69.1,33.02 66.2,30.13 51.72,30.13 46.64,25.05 43.84,25.05 42.85,24.05 35.44,24.05 33.55,25.94 25.05,25.94 23.49,24.38 23.49,21.59 22.35,20.45 22.35,18.15 TP26.1 v1(23,16.5)
GP47: length 76.2
  TOP w0.127: v1(70,44.45) 69.75,44.21 U8.C1 ; v1(23,19) 23.5,18.51 23.5,16.13 23.3,15.93 J7.30
  BOTTOM w0.127: v1(23,19) TP28.1 23,20.7 23.88,21.58 23.88,24.26 25.3,25.68 33.3,25.68 35.28,23.7 42.88,23.7 43.97,24.79 56.03,24.79 61.11,29.87 68.07,29.87 71.35,33.14 71.35,38.93 70,40.28 70,41.15 69.82,41.33 69.82,44.28 v1(70,44.45)
GP48: length 60.9
  TOP w0.127: v1(24.5,19) 23.88,18.38 23.88,15.88 23.7,15.7 J7.32 ; v1(73.85,14.83) 74.09,15.07 U32.C1
  BOTTOM w0.127: v1(73.85,14.83) 73.85,14.41 72.77,13.34 49.02,13.34 46.86,15.49 42.04,15.49 41.63,15.9 33.81,15.9 33.15,15.24 26.54,15.24 25.27,16.51 25.27,18.23 v1(24.5,19) TP29.1
GP49: length 60.2
  TOP w0.127: v1(24.5,16.5) 24.13,16.13 24.13,15.77 24.1,15.74 J7.34 ; U30.C1 78.16,15.07 v1(77.91,14.83)
  BOTTOM w0.127: TP31.1 v1(24.5,16.5) 26.14,14.86 33.15,14.86 33.81,15.52 40.87,15.52 41.27,15.11 46.86,15.11 48.9,13.08 76.17,13.08 v1(77.91,14.83)
GP77: length 59.6
  TOP w0.127: R45.2 35.98,54.5 36.09,54.61 36.09,55.35 32.89,58.55 32.89,62.46 J5.9 ; R45.2 35.78,54.34 36.17,53.95 U35.A3 ; R45.2 35.78,54.89 35.69,54.99 34.16,54.99 33.78,54.61 33.78,50.17 29.6,45.98 29.6,39.59 30.65,38.54 30.65,29.85 30.5,29.7 v1(30.5,21.5) 29.96,20.96 29.96,18.91 29.59,18.54 29.59,16.13 29.3,15.84 J7.60
  BOTTOM w0.127: TP52.1 v1(30.5,21.5)
GP78: length 51.3
  TOP w0.127: v1(39.9,50.35) 39.9,52.75 v2(39.1,53.55) ; J7.58 28.9,16.4 v1(29,16.5) 29,18.33 29.59,18.92 29.59,29.19 30.35,29.95 30.35,37.65 29,39 29,46.15 v1(32.77,49.91)
  GND w0.127: v2(37.9,53.55) v2(39.1,53.55)
  BOTTOM w0.127: TP50.1 v1(29,16.5) ; v1(32.77,49.91) 39.46,49.91 v1(39.9,50.35)
GP79: length 46.4
  TOP w0.127: v1(33.66,49.02) 30.08,45.45 30.08,39.98 31.12,38.94 31.12,21.34 30.5,20.72 v1(30.5,19) 29.97,18.47 29.97,15.88 29.7,15.6 J7.62 ; U35.C1 37.5,52.95 37.95,52.5 37.95,49.63 v1(37.34,49.02)
  BOTTOM w0.127: v1(37.34,49.02) v1(33.66,49.02) ; TP54.1 v1(30.5,19)
GP80: length 45.3
  TOP w0.127: v1(34.54,48.01) 31.15,44.61 31.15,40.16 32,39.31 v1(32,21.5) 32,20.44 31.37,19.81 31.37,17.78 30.99,17.4 30.99,15.62 30.5,15.13 J7.66 ; U35.D1 37.9,52.95 38.25,52.6 38.25,49.3 v1(36.96,48.01)
  BOTTOM w0.127: v1(36.96,48.01) v1(34.54,48.01) ; TP58.1 v1(32,21.5)
GP81: length 45.1
  TOP w0.127: U35.E1 38.55,52.9 38.55,48.46 37.59,47.5 35.4,47.5 32,44.1 32,41.1 33.15,39.96 33.15,19.81 32.77,19.43 32.77,17.27 v1(32,16.5) 32,16.5 32,15.75 31.3,15.04 J7.70
  BOTTOM w0.127: TP62.1 v1(32,16.5)
GP82: length 43.2
  TOP w0.127: J7.64 30.1,15.22 30.5,15.62 v1(30.5,16.5) 30.5,17.67 31.12,18.29 31.12,20.57 31.5,20.96 31.5,39.1 30.65,39.95 30.65,44.84 36.32,50.51 36.32,52.2 36.7,52.57 U35.A1
  BOTTOM w0.127: TP56.1 v1(30.5,16.5)
GP83: length 43.7
  TOP w0.127: U35.B1 37.1,52.95 37.65,52.4 37.65,50.35 31.61,44.31 31.61,40.61 32.64,39.58 32.64,20.19 32,19.55 v1(32,19) 32,17.78 31.37,17.15 31.37,15.49 30.9,15.03 J7.68
  BOTTOM w0.127: TP60.1 v1(32,19)
GP84: length 51.2
  TOP w0.127: U35.E2 38.55,53.55 39.05,53.05 v1(39.05,51.25) ; v1(32.5,50.9) 28.5,46.9 28.5,38.95 30.05,37.4 30.05,30.05 29.1,29.1 29.1,25.55 27.05,23.5 27,23.5 25.55,22.05 25.55,15.9 26.1,15.35 J7.44
  BOTTOM w0.127: TP87.1 v1(39.05,51.25) 32.85,51.25 v1(32.5,50.9)
GP109: length 123.3
  TOP w0.127: v1(89.94,25.3) 89.94,20.47 90.2,20.22 U43.C2 ; v1(92.86,15.65) 92.86,13.24 92.48,12.85 92.48,7.9 89.15,4.57 72.9,4.57 71.37,3.05 32.26,3.05 31.75,3.56 30.73,3.56 30.23,3.05 29.34,3.05 29.08,3.3 29.08,4.06 29.97,4.95 29.97,5.97 29.5,6.44 v1(29.5,8) 29.5,8.89 28.5,9.89 J7.55 ; v1(100.33,37.47) 99.44,37.47 98.98,37 U3.17
  BOTTOM w0.127: v1(100.33,37.47) 100.08,37.21 100.08,34.04 99.27,33.23 99.27,28.35 96.22,25.3 v1(89.94,25.3) 93.12,22.12 93.12,15.9 v1(92.86,15.65) ; TP49.1 v1(29.5,8)
GP110: length 132.1
  TOP w0.127: J7.53 28.1,9.87 28.96,9.02 28.96,6.04 v1(29.5,5.5) ; v1(106.83,28.73) 106.33,28.22 101.63,28.22 100.97,28.88 100.97,30.35 101.12,30.51 101.12,33.96 101.73,34.57 101.73,36.07 100.97,36.83 99.57,36.83 99.24,36.5 U3.16
  BOTTOM w0.127: v1(29.5,5.5) TP47.1 30.19,3.81 36.09,3.81 38.79,6.5 53.21,6.5 55.91,3.81 104.01,3.81 109.9,9.69 109.9,13.28 110.74,14.12 110.74,25.71 107.72,28.73 v1(106.83,28.73)
GP111: length 111.4
  TOP w0.127: J7.51 27.7,9.64 28.57,8.76 28.57,6.08 v1(28,5.5) 28,4.19 28.6,3.58 28.6,2.95 29.11,2.44 71.66,2.44 72.8,3.58 89.18,3.58 92.86,7.27 92.86,12.35 93.75,13.24 v1(93.75,17.3) ; v1(98.33,25.17) 99.18,25.17 U44.1 100.64,26.47 100.74,26.57 102.52,26.57 103.02,27.08 106.71,27.08 107.47,27.84 107.47,31.27 107.08,31.65 U40.C2
  BOTTOM w0.127: v1(93.75,17.3) 98.33,21.87 v1(98.33,25.17) ; TP45.1 v1(28,5.5)
GP114: length 110.8
  TOP w0.127: v1(88.07,14.83) 87.5,14.26 87.5,8.29 84.55,5.33 72.52,5.33 70.48,3.3 32.51,3.3 31,4.81 v1(31,5.5) 31,6.72 30.48,7.24 30.48,8.76 29.3,9.94 J7.59 ; U3.19 97.5,38.61 97.63,38.73 v1(99.7,38.73) ; 99.95,27.17 99.92,27.21 v1(99.34,27.21)
  BOTTOM w0.127: TP53.1 v1(31,5.5) ; v1(88.07,14.83) 89.06,13.84 92.01,13.84 98.83,20.66 98.83,26.7 v1(99.34,27.21) 99.7,27.56 99.7,33.15 100.46,33.91 100.46,36.2 100.84,36.58 100.84,37.59 v1(99.7,38.73)
GP115: length 144.2
  TOP w0.127: U41.C2 107.73,34.7 108.36,35.33 v1(108.36,38.22) 106.8,39.78 105.56,39.78 102.52,39.78 100.71,37.97 99.31,37.97 98.84,37.5 U3.18 ; J7.57 28.9,9.96 30.1,8.76 30.1,6.48 30.35,6.22 30.35,3.85 30.06,3.56 v1(29.59,3.56)
  BOTTOM w0.127: v1(108.36,38.22) 108.36,37.77 110.55,35.58 110.55,31.68 108.74,29.87 108.74,28.09 110.97,25.86 110.97,25.84 111,25.81 111,14.02 110.97,13.99 110.97,10 104.52,3.56 55.68,3.56 52.99,6.25 39.17,6.25 36.48,3.56 v1(29.59,3.56) 29.5,3.47 TP51.1
GP128: length 42.8
  TOP w0.127: J7.65 30.5,10 v1(32.5,8) 33.27,7.23 33.27,5.21 33.66,4.83 49.28,4.83 55.05,10.6 59.63,10.6 60.71,11.68 60.71,14.84 U29.C1
  BOTTOM w0.127: TP59.1 v1(32.5,8)
GP129: length 49.4
  TOP w0.127: U24.C1 65.79,14.84 65.79,11.18 64.52,9.91 55.12,9.91 49.4,4.19 33.4,4.19 32.5,5.09 v1(32.5,5.5) 32.5,6.49 31.62,7.37 31.62,8.38 30.1,9.9 J7.63
  BOTTOM w0.127: TP57.1 v1(32.5,5.5)
GP130: length 41.4
  TOP w0.127: J7.61 29.7,9.92 30.99,8.64 30.99,8.01 v1(31,8) 31,7.1 31.75,6.35 31.75,5.08 33.15,3.68 50.04,3.68 v1(55.24,8.89) ; v1(55.24,12.07) 55.24,14.46 U33.C1
  BOTTOM w0.127: TP55.1 v1(31,8) ; v1(55.24,12.07) v1(55.24,8.89)
GP131: length 45.9
  TOP w0.127: J7.46 26.5,15.35 26,15.85 v1(26,16.5) ; v1(58.61,14.83) 58.85,15.07 U31.C1
  BOTTOM w0.127: TP39.1 v1(26,16.5) 26.85,15.65 32.16,15.65 33.43,16.92 39.14,16.92 45.37,23.14 48.03,23.14 52.07,19.1 52.07,16 53.72,14.35 58.13,14.35 v1(58.61,14.83)
GP134: length 97.7
  TOP w0.127: R7.2 106.14,5.21 v1(102.87,5.21) ; J7.22 21.7,18.3 v1(21.46,18.54)
  BOTTOM w0.127: v1(102.87,5.21) 55.93,5.21 53.24,7.9 43.28,7.9 40.45,10.73 40.45,13.27 38.71,15.01 33.68,15.01 33.15,14.48 23.52,14.48 21.5,16.5 TP20.1 21.5,18.51 v1(21.46,18.54)
GP135: length 97.9
  TOP w0.127: R9.2 108.74,1.93 108.1,1.3 23.7,1.3 v1(22,3) 23,4 23,8.14 23.37,8.51 23.37,10.16 22.9,10.63 J7.27
  BOTTOM w0.127: TP27.1 v1(22,3)
GP165: length 99
  TOP w0.127: v1(74.5,44.45) 74.25,44.21 U4.C1 ; v1(48.16,5.62) 51.21,8.66 51.21,18.06 v1(61.24,28.09) ; v1(22,5.5) 22.48,5.98 22.48,8 22.99,8.51 22.99,10.03 22.5,10.52 J7.25
  BOTTOM w0.127: v1(74.5,44.45) 75.46,43.49 75.46,39.85 75.25,39.65 75.25,38.89 75.92,38.22 75.92,34.26 74.32,32.67 71.91,32.67 68.1,28.86 62,28.86 v1(61.24,28.09) ; v1(22,5.5) TP25.1 21.9,4.5 21.11,3.71 20.35,3.71 19.84,3.2 19.84,1.55 20.22,1.17 43.72,1.17 v1(48.16,5.62)
GP182_PWM2: length 29.4
  TOP w0.127: J7.37 24.9,8.1 v1(25,8) ; J12.4 45.24,13.08 42.93,13.08 38.73,8.89 34.8,8.89 v1(34.16,9.53)
  BOTTOM w0.127: v1(34.16,9.53) 33.58,9.53 32.79,10.31 27.31,10.31 v1(25,8) TP35.1
GP183_PWM3: length 33.4
  TOP w0.127: v1(25,3) 25.5,3.5 25.5,8.66 25.3,8.86 J7.39 ; J11.4 37.87,5.72 v1(35.56,5.72)
  BOTTOM w0.127: TP36.1 v1(25,3) 25.78,3.78 25.78,5.46 26.59,6.27 35,6.27 v1(35.56,5.72)
GPI_PWRBTN_N: length 90.4
  TOP w0.127: J7.17 20.9,10.18 20.57,9.86 20.14,9.86 19.76,9.47 19.76,6.24 v1(20.5,5.5)
  TOP w0.3: R49.1 v1(13.75,66.71)
  BOTTOM w0.127: TP17.1 v1(20.5,5.5) 20.03,5.97 16.34,5.97 15.11,7.2 15.11,16.52 2.03,29.59 2.03,65.15 3.59,66.71 v1(13.75,66.71)
GPI_PWRBTN_N_L: length 5.6
  TOP w0.3: R48.2 18.62,68.41 SW1UI2.1 15.87,68.03 R49.2
MSIC_SLPCLK_2: length 9
  TOP w0.127: J7.7 18.9,10.47 17.07,8.64 16.51,8.64 v1(16.13,8.26)
  BOTTOM w0.127: v1(16.13,8.26) 16.59,8.71 18.47,8.71 19,8.18 TP8.1
OSC_CLK_OUT_0: length 8.2
  TOP w0.127: J7.67 30.9,10.12 32.38,8.64 32.64,8.64 34,7.28 v1(34,5.5)
  BOTTOM w0.127: TP61.1 v1(34,5.5)
PSW: length 55.1
  TOP w0.127: v1(22.61,27.56) 27.68,32.63 U36.4 ; J7.21 21.7,9.49 R37.1 21.89,9.48 22.1,9.27 22.1,8.64 21.46,8 21.46,3.96 v1(20.5,3)
  BOTTOM w0.127: v1(22.61,27.56) 22.37,27.56 15.79,20.97 15.79,19 16.99,17.8 16.99,14.35 18.37,12.97 20.18,12.97 24.13,9.02 24.13,6.35 23.88,6.1 23.24,6.1 22.73,5.59 22.73,3.94 22.25,3.46 20.96,3.46 v1(20.5,3) TP21.1
PWM0_OUT: length 24.9
  TOP w0.127: R91.1 62.96,15.53 U27.C1 63.93,15.07 v1(63.69,14.83)
  BOTTOM w0.127: v1(63.69,14.83) 62.96,14.1 52.96,14.1 51.18,15.88 51.18,19.3 48.69,21.79 J12.1
PWM1_OUT: length 29.7
  TOP w0.127: R90.1 68.06,15.53 U21.C1 69.01,15.07 v1(68.77,14.83)
  BOTTOM w0.127: J11.1 45.01,18.03 47.75,18.03 51.94,13.84 67.79,13.84 v1(68.77,14.83)
PWM2_OUT: length 28.8
  TOP w0.127: v1(71.31,14.83) 71.55,15.07 U19.C1 70.6,15.53 R89.1
  BOTTOM w0.127: J12.3 49.45,13.59 70.07,13.59 v1(71.31,14.83)
PWM3_OUT: length 40.1
  TOP w0.127: v1(80.45,14.83) 80.7,15.07 U28.C1 79.72,15.53 R92.1
  BOTTOM w0.127: J11.3 45.14,12.83 78.45,12.83 v1(80.45,14.83)
PWM4_OUT: length 79.8
  TOP w0.127: v1(101.98,29.54) 101.98,30.98 R94.1 101.98,31.42 101.98,32.23 102.75,33
  BOTTOM w0.127: v1(101.98,29.54) 102.77,28.75 102.77,23.01 92.39,12.63 92.39,6.86 91.75,6.22 56.31,6.22 50.9,11.63 J12.5
PWM5_OUT: length 93.5
  TOP w0.127: R93.1 102.2,35.7 102,35.9 102,36.2 101.6,36.6 v1(101.6,36.83) 102.33,36.83 U22.B2
  BOTTOM w0.127: v1(101.6,36.83) 104.01,36.83 104.52,36.32 104.58,36.32 106.96,33.94 106.96,31.42 104.52,28.98 104.52,24.13 95,14.6 95,8.76 91.95,5.72 56.06,5.72 52.68,9.09 J11.5
RCVR_MODE: length 85.6
  TOP w0.127: v1(6.99,65.41) 6.6,65.79 6.6,67.82 6.01,68.41 SW1UI4.1 ; J7.31 23.7,8.2 v1(23.5,8)
  BOTTOM w0.127: TP30.1 v1(23.5,8) 21.72,8 21.21,7.49 21.21,6.6 20.96,6.35 16.55,6.35 15.42,7.48 15.42,16.69 5.33,26.77 5.33,28.45 2.92,30.86 2.92,63.12 5.21,65.41 v1(6.99,65.41)
RESETOUT#: length 64.4
  TOP w0.127: v1(35.65,46.65) 35.3,46.65 32.5,43.85 32.5,41.4 33.65,40.25 33.65,39.35 34.05,38.95 36.4,38.95 36.53,38.83 Q8.1 ; R123.2 29.68,53.8 30.55,53.8 31.55,52.8 v1(31.55,51.05) ; J7.36 24.5,15.61 24.95,16.06 24.95,21.05 v1(24.5,21.5)
  TOP w0.2: Q8.1 R85.1 34.67,36.7 34.11,36.14 v1(34.11,22.63)
  BOTTOM w0.127: v1(35.65,46.65) 33.2,46.65 31.55,48.3 v1(31.55,51.05)
  BOTTOM w0.2: v1(34.11,22.63) 34.11,24.11 32.92,25.3 25.81,25.3 24.5,23.99 TP33.1 v1(24.5,21.5)
SD_CLK: length 16.6
  TOP w0.127: J5.5 38.33,67.24 37.67,66.57 v2(37.67,54.76)
  GND w0.127: v2(37.67,54.76) 37.9,54.53 v2(37.9,53.95)
SD_CMD: length 16.4
  TOP w0.127: J5.3 36.13,67.96 37.29,66.8 37.29,54.64 37.5,54.42 U35.C4
SD_DAT0: length 16.9
  TOP w0.127: J5.7 40.53,68.47 38,65.94 38,54.45 U35.D4
SD_DAT1: length 17.2
  TOP w0.127: J5.8 41.58,68.53 38.3,65.25 U35.E4
SD_DAT2: length 17
  TOP w0.127: U35.A4 36.7,66.07 33.93,68.83 J5.1
SD_DAT3: length 16.7
  TOP w0.127: J5.2 35.03,68.34 36.98,66.4 36.98,54.47 U35.B4
SHLD_RESET: length 113.3
  TOP w0.25: U17.8 v1(59.71,45.5)
  TOP w0.3: v1(55.5,50.48) 55.5,49.59 56.25,48.84 U17.17
  TOP w0.33: J4.5 55.5,38.45 54.53,38.45 54.2,38.78 R19.1 53.95,39.25 53.95,39.26 C34.1
  TOP w0.5: v1(82.42,62.46) 82.4,62.48 v1(53.49,62.48) 53.47,62.48 51.63,60.65 51.63,60.63 50.29,59.29 50.29,52.07 51.69,50.67 55.31,50.67 v1(55.5,50.48) ; SW1UI1.1 v1(22.5,66.7)
  BOTTOM w0.5: v1(22.5,66.7) 46.46,66.7 50.67,62.48 v1(53.49,62.48) ; J4.5 60.5,41.07 60.5,44.91 60,45.41 59.89,45.41 59.85,45.45 59.77,45.45 59.72,45.51 ; 59.72,45.51 v1(59.71,45.5) ; 59.72,45.51 59.72,47.79 57.4,50.1 55.88,50.1 v1(55.5,50.48) ; v1(82.42,62.46) 86.26,62.46 87.3,61.42 J2A1.3
SPI_CLK_SEL: length 62.8
  TOP w0.127: v1(68.99,52.99) 69,52.97 U16.13 ; v1(61.75,32.92) 62.13,32.54 62.77,32.54 64.92,30.38 85.88,30.38 90.45,25.81 90.45,21.23 U43.D2
  BOTTOM w0.127: v1(68.99,52.99) 68.1,52.99 66.45,51.34 66.45,49.56 65.69,48.8 64.29,48.8 61,45.51 61,36.59 61.75,35.84 v1(61.75,32.92)
SPI_FS_SEL: length 57.9
  TOP w0.127: v1(106.7,30.13) U40.D2 ; v1(108.99,35.21) 108.99,40.13 108.71,40.41 99.72,40.41 98.96,41.18 84.1,41.18 83.09,40.16 79.68,40.16 74.35,45.49 73.05,45.49 71.91,46.64 71.91,48.92 70.64,50.19 70.51,50.19 70.2,50.5 U16.10
  BOTTOM w0.127: v1(108.99,35.21) 108.36,34.57 108.36,31.65 106.83,30.13 v1(106.7,30.13)
SPI_RXD_SEL: length 62.7
  TOP w0.127: U42.D2 88.55,22.13 88.8,22.38 88.8,26.82 85.5,30.13 63.53,30.13 v1(62,31.65) ; U16.12 69.91,51.5 v1(70.39,51.97)
  BOTTOM w0.127: v1(70.39,51.97) 69.24,50.83 69.24,49.56 67.97,48.29 64.29,48.29 61.4,45.4 61.4,37.46 62.38,36.48 62.38,32.54 62,32.16 v1(62,31.65)
SPI_TXD_SEL: length 55.2
  TOP w0.127: U41.D2 108.88,34.2 109.61,34.93 109.61,40.02 108.41,41.22 99.42,41.22 99.21,41.43 83.85,41.43 82.96,40.54 79.72,40.54 74.47,45.79 73.26,45.79 72.34,46.72 72.34,49.64 70.97,51 U16.11
TRI_STATE_ALL: length 45.2
  TOP w0.127: Q7.5 R35.2 82.03,43.32 v1(82.05,43.3)
  TOP w0.3: U17.16 v1(56.75,49.07)
  PWR_GND w0.127: v1(82.05,43.3) 82.65,43.3 83.6,42.35 83.6,40.1 80.35,36.85 61.4,36.85 56.7,41.55 56.7,42.71 56.26,43.15 56.26,44.2 55.82,44.64 55.82,47.17 55.8,47.19 55.8,48.12 v1(56.75,49.07)
USB_DN: length 133.9
  TOP w0.112: 116.36,29.63 v1(116.36,29.62) ; 116.36,29.63 116.87,30.14 118.04,30.14 118.15,30.03 118.15,28.07 117.02,26.94 110.32,26.94 109.6,26.22 109.6,25.96 v1(109.32,25.68) ; 116.36,29.63 116.36,30.02 116.25,30.13 115.99,30.13 115.61,30.52 115.49,30.52 115.36,30.39 EU1.7 ; v1(19.81,16.64) 20.83,15.62 20.83,14.95 20.9,14.88 J7.18
  BOTTOM w0.112: v1(109.32,25.68) 109.6,25.4 109.6,15.27 109.26,14.93 109.26,10.71 103.12,4.57 56.02,4.57 53.34,7.25 43.31,7.25 39.75,10.81 39.75,12.95 37.96,14.74 33.92,14.74 33.02,13.84 22.99,13.84 20.74,16.09 19.6,16.09 19.49,16.2 19.49,16.31 v1(19.81,16.64)
USB_DP: length 135.7
  TOP w0.112: v1(110.12,25.68) 109.84,25.96 109.84,26.12 110.42,26.7 117.12,26.7 118.39,27.97 118.39,30.13 118.14,30.38 116.87,30.38 v1(116.36,30.89) 116.36,30.48 116.25,30.37 116.09,30.37 115.7,30.76 115.49,30.76 115.36,30.89 EU1.8 ; v1(18.92,16.64) 19.43,16.13 19.98,16.13 20.59,15.52 20.59,14.97 20.5,14.88 J7.16
  BOTTOM w0.112: v1(18.92,16.64) 19.25,16.31 19.25,16.1 19.5,15.85 20.64,15.85 22.89,13.6 33.12,13.6 34.02,14.51 37.86,14.51 39.51,12.86 39.51,10.71 43.21,7.01 53.24,7.01 55.92,4.33 103.22,4.33 109.5,10.61 109.5,14.83 109.84,15.17 109.84,25.4 v1(110.12,25.68)
USB_ID: length 148.9
  TOP w0.127: v1(112.04,1.4) 111.56,0.92 108.41,0.92 108.41,0.92 20.93,0.92 19.81,2.03 19.81,3.56 19,4.37 v1(19,5.5) 17.16,5.5 15.62,7.04 15.62,8.89 16.19,9.46 17.08,9.46 17.35,9.73 17.35,10.31 17.55,10.52 17.97,10.52 18.1,10.64 J7.3 ; v1(110.85,37.36) Q11.3
  BOTTOM w0.127: TP4.1 v1(19,5.5) ; v1(112.04,1.4) 112.04,9.77 111.27,10.54 111.27,25.94 108.99,28.22 108.99,29.49 110.85,31.35 110.85,37.36 v1(110.85,37.36)
USBA_CONN_DN: length 23.6
  TOP w0.112: EU1.2 111.26,31.39 111.13,31.52 110.87,31.52 110.41,31.99 110.41,33.41 110.01,33.8 110.01,40.12 112.7,42.81 114.99,42.81 116.12,43.94 116.12,47.17 115.75,47.54 114.76,47.54 J6.2
USBA_CONN_DP: length 23.6
  TOP w0.112: J6.3 113.95,48.67 114.84,47.78 115.85,47.78 116.36,47.27 116.36,43.84 115.09,42.57 112.8,42.57 110.25,40.02 110.25,33.9 110.64,33.51 110.64,32.09 110.97,31.76 111.13,31.76 111.26,31.89 EU1.1
V_1P80: length 116.2
  TOP w0.2: U42.A2 88.55,19.08 88.17,18.7 v1(87.91,18.7) ; U44.6 99.5,26.47 v1(99.34,26.32) ; v1(107.47,36.22) 106.95,35.7 U41.A2 ; U43.A2 90.45,18.7 90.45,18.51 v1(90.44,18.51) ; 107.61,32.65 U40.A2
  TOP w0.23: v1(73.83,17.23) 74.09,16.96 U32.A1 ; U35.A2 36.33,53.55 C31.2 ; C20.2 63,42.03 U14.A1 ; C19.2 65.25,42.03 U12.A1 ; U4.A1 74.25,42.03 C15.2 ; v1(77.89,17.23) 78.16,16.96 U30.A1 ; U10.A1 67.5,42.03 C18.2 ; v1(80.43,17.23) 80.7,16.96 U28.A1 79.8,16.53 79.53,16.26 ; v1(102.5,36.05) 102.75,36.3 U22.A2 ; v1(66.21,17.23) 66.47,16.96 U24.A1 ; C16.2 72,42.03 U6.A1 ; v1(87.78,16.92) 87.93,16.92 U20.A1 ; v1(85.51,17.23) 85.78,16.96 U23.A1 ; v1(71.29,17.23) 71.55,16.96 U19.A1 70.68,16.53 70.41,16.26 ; U31.A1 58.85,16.96 v1(58.59,17.23) ; v1(90.45,17.05) 90.63,17.05 90.86,16.82 U18.A1 ; v1(102.5,31.8) 102.75,32.05 102.75,32.5 ; U33.A1 56.31,16.96 v1(56.05,17.23) ; v1(68.75,17.23) 69.01,16.96 U21.A1 68.14,16.53 67.87,16.26 ; U8.A1 69.75,42.03 C17.2 ; U29.A1 61.39,16.96 v1(61.13,17.23) ; U26.A1 83.24,16.96 v1(82.97,17.23) ; v1(63.67,17.23) 63.93,16.96 U27.A1 63.04,16.53 62.76,16.26
  TOP w0.25: R85.2 33.84,38.35 v1(33.81,38.38)
  TOP w0.3: v1(63.15,51.75) R44.2 ; U3.21 C14.2 96.97,39.47 C13.1 v1(97.86,39.75) ; v1(21.08,9.14) 20.88,8.94 R36.2 ; C18.2 v1(68.15,42) ; v1(73.62,53) R40.2 73.03,52.47 Q4.1 ; v1(102.5,31.8) 102.73,31.57 R94.2 ; v1(102.5,36.05) 102.73,35.82 R93.2 ; v1(28.46,52.85) R102.1 26.9,52.04 Q13.4 ; C19.2 v1(65.9,42) ; U2.1 108.26,2.94 C10.2 102.92,2.67 97.82,7.77 v1(97.82,14.25) ; R43.2 v1(63.1,51) ; C15.2 v1(74.9,42) ; R47.2 11.29,61.97 v1(11.3,61.98) ; v1(78.57,53) R39.2 78.03,52.47 Q3.1 ; R45.1 v1(34.63,54.5) ; C20.2 v1(63.65,42) ; C16.2 v1(72.65,42) ; C31.2 v1(35.78,52.39) ; R46.1 v1(40.62,54) ; v1(63.22,53.55) C22.2 ; v1(44.48,28.48) 44.5,28.45 R87.2 ; v1(109.63,33.43) 108.85,32.65 107.61,32.65 ; C17.2 v1(70.4,42)
  TOP w0.5: v1(83.19,34.93) 83,34.74 Q5.1 ; J15.2 20.81,38.64 R82.1 ; Q6.1 87.5,34.42 v1(87,34.93)
  PWR_GND w0.381: J15.2 20,40.36 ; J15.2 20,38.54 ; J15.2 19.09,39.45 ; J15.2 20.91,39.45
  BOTTOM w0.3: TP11.1 J15.2
  BOTTOM w0.5: v1(21.08,9.14) 21.08,9.48 16.42,14.14 16.42,17.02 15.3,18.14 15.3,21.4 22.61,28.7 26.16,28.7 v1(26.67,29.21)
V_1P80_IO: length 7.1
  TOP w0.127: C21.2 64.17,49.11 R122.2
  TOP w0.25: U34.18 v1(70.32,26.25) ; U34.21 v1(67.75,27.84) ; C21.2 v1(64.92,50.06) ; U34.23 v1(66.75,27.84)
  TOP w0.3: U16.21 65.23,50.5 64.92,50.19 v1(64.92,50.06) 64.92,49.68 65.11,49.5 U16.23
  vias: v1(21.74,52.1) v1(22.51,52.1)
V_3P30: length 16.2
  TOP w0.25: v1(116.36,32.29) 115.96,31.89 EU1.10
  TOP w0.3: R83.1 14.56,38.64 J14.2
  BOTTOM w0.381: 13.75,38.54 J14.2 ; J14.2 12.84,39.45 ; J14.2 14.66,39.45 ; J14.2 13.75,40.36 ; J9.3 85,54.8 ; J9.3 85.97,53.83 ; J9.3 84.03,53.83 ; J9.3 85,52.86 ; J2A1.4 84.76,61.09 ; J2A1.4 84.76,59.16 ; J2A1.4 85.73,60.12 ; J2A1.4 83.79,60.12
V_SHIELD: length 29.1
  TOP w0.225: R114.2 54.55,40.2 54.67,40.08
  TOP w0.23: C30.2 69.75,41.26 U9.A2 ; C25.2 74.25,41.26 U5.A2 ; C28.2 67.5,41.26 U11.A2 ; U15.A2 63,41.26 C23.2 ; U7.A2 72,41.26 C29.2 ; C24.2 65.25,41.26 U13.A2
  TOP w0.25: v1(28.48,48.8) 28.46,48.78 R100.1
  TOP w0.3: v1(66,40.56) 66,40.87 65.58,41.3 C24.2 ; v1(70.5,40.56) 70.5,40.87 70.08,41.3 C30.2 ; v1(68.25,40.56) 68.25,40.87 67.83,41.3 C28.2 ; R12.1 v1(80.72,42.75) ; R42.2 v1(75.34,47) ; R114.2 55.09,40.57 55.09,40.57 ; v1(75,40.56) 75,40.87 74.58,41.3 C25.2 ; 54.63,39.78 R19.2 ; R41.2 v1(79.65,47) ; C23.2 63.33,41.3 63.75,40.87 v1(63.75,40.56) ; Q7.4 v1(82.05,44.7) ; 26.21,47.97 26.9,47.97 R100.1 ; v1(72.75,40.56) 72.75,40.87 72.33,41.3 C29.2 ; R34.1 v1(80.73,42)
  TOP w0.381: 84.03,51.29 J9.2 ; J9.2 85,52.26 ; J9.2 85.97,51.29 ; J8.1 92.5,49.72 ; J8.1 91.53,48.75 ; J8.1 93.47,48.75 ; J8.1 92.5,47.78
  vias: v1(60.15,35.68) v1(60.15,34.85) v1(60.16,34) v1(76.2,33.02) v1(76.58,40.39) v1(76.86,34.95) v1(77.5,33.3) v1(77.85,40.39) v1(77.85,39.12) v1(78,34.19) v1(78.64,33.3) v1(78.74,34.93) v1(79.63,34.42)
V_SHIELD_SW: length 17.3
  TOP w0.23: U19.A2 72.06,16.98 v1(72.3,17.23) ; U10.A2 v1(66.48,42.75) ; v1(67.22,17.23) 66.98,16.98 U24.A2 ; U32.A2 74.6,16.98 v1(74.84,17.23) ; v1(64.68,17.23) 64.44,16.98 U27.A2 ; v1(81.45,17.23) 81.2,16.98 U28.A2 ; v1(83.99,17.23) 83.74,16.98 U26.A2 ; v1(78.91,17.23) 78.66,16.98 U30.A2 ; v1(89.05,17.05) 89.05,17.05 88.82,16.82 U20.A2 ; v1(57.06,17.23) 56.82,16.98 U33.A2 ; U8.A2 v1(68.73,42.75) ; U14.A2 v1(61.98,42.75) ; U6.A2 v1(70.98,42.75) ; U21.A2 69.52,16.98 v1(69.76,17.23) ; v1(62.14,17.23) 61.9,16.98 U29.A2 ; U18.A2 91.36,16.98 v1(91.61,17.23) ; U23.A2 86.28,16.98 v1(86.53,17.23) ; U12.A2 v1(64.23,42.75) ; U31.A2 59.36,16.98 v1(59.6,17.23) ; U4.A2 v1(73.23,42.75)
  TOP w0.3: Q7.2 v1(86.93,43.75) 87.54,43.75 R125.2 ; Q7.3 v1(87,44.7)
V_SHLD_IO: length 21.4
  TOP w0.127: v1(85.24,26.32) 85.18,26.25 U39.18 ; 53.3,43.1 v1(53.2,43.2) ; v1(82.2,28.48) 82.2,28.47 C27.2 U39.21
  TOP w0.25: v1(53.24,45.75) 53.53,46.04 C26.2
  TOP w0.3: U17.21 C26.2 ; R121.2 60.73,43.97 60.5,44.2 59.2,44.2 v1(59.15,44.25)
  TOP w0.33: v1(84.75,29.36) 84.42,29.03 R51.2 ; R117.2 R116.2 53.3,43.1 ; R121.2 R120.2 R119.2 R118.2 ; R50.2 83.5,29.25 v1(83.2,29.55)
  BOTTOM w0.127: v1(85.24,26.32) 84.36,26.32 v1(82.2,28.48)
  BOTTOM w0.225: v1(54.6,43.8) v1(55.05,44.25)
  BOTTOM w0.3: v1(55.05,44.25) v1(59.15,44.25)
  vias: v1(21.74,48.03) v1(22.51,48.03)
V_SYS: length 43.1
  TOP w0.2: R88.2 44.96,29.9 v1(44.1,30.76)
  TOP w0.25: C5.1 43.25,32.5 U38.11 ; v1(46.38,30.76) 46.89,31.27 R113.2
  TOP w0.3: v1(34.19,39.85) 34.2,39.86 R86.2 ; Q14.4 v1(27.28,55.85) R104.1 ; v1(43.88,32.5) C5.1 ; C32.2 37,52.24 v1(37.08,52.32) ; v1(21.8,59.95) 20.7,59.95 19.46,58.71 R105.1 ; R48.1 19,63.04 20.96,61.09 v1(22.99,61.09)
  GND w0.3: v2(37.1,53.55) 37.08,53.53 v1(37.08,52.32)
  BOTTOM w0.3: 21.75,33.15 21.7,33.1 12.6,33.1 9.4,36.3 9.4,41.55 8,42.95 TP3.1
V_SYSTEM: length 9.5
  TOP w0.127: C49.2 R106.1 23.61,56.78 Q14.2 Q14.3
  TOP w0.3: R84.1 8.31,38.64 J10.2
  TOP w0.381: J10.2 8.41,39.45 ; J10.2 7.5,38.54 ; J10.2 7.5,40.36 ; J10.2 6.59,39.45
V_VBAT_BKUP: length 6.2
  TOP w0.203: v1(21.97,6.22) 21.97,7.97 22.48,8.48 22.48,9.78 22.1,10.16 J7.23
  BOTTOM w0.3: v1(21.97,6.22) 22,6.25 TP23.1
N11374: length 11.4
  TOP w0.112: J3.2 118.25,5.87 118.46,6.07 118.57,6.07 118.68,5.96 118.68,4.99 118.31,4.62 115.34,4.62 114.71,5.25 ; 114.71,5.25 v1(114.71,5.27) ; 114.71,5.25 114.71,4.86 114.6,4.75 114.26,4.75 113.82,5.19 113.82,6.74 113.57,6.99 112.93,6.99 112.8,7.12 U2.15
N11378: length 12.1
  TOP w0.112: J3.3 118.25,6.52 118.46,6.31 118.67,6.31 118.92,6.06 118.92,4.89 118.41,4.38 115.09,4.38 v1(114.71,4) 114.71,4.4 114.6,4.51 114.16,4.51 113.58,5.09 113.58,6.64 113.47,6.75 112.93,6.75 112.8,6.62 U2.14
N30036849: length 0.9
  TOP w0.127: R8.2 111.26,9.09 U2.18
N30040341: length 25.5
  TOP w0.127: J5.4 37.23,71.02 37.11,71.15 33.4,71.15 33.05,70.79 33.05,68.5 36.42,65.13 36.42,54.58 36.3,54.46 v2(36.3,54.31)
  GND w0.127: v2(36.3,54.31) 35.91,54.31 35.78,54.18 v2(35.78,53.75) 36.58,53.75 36.78,53.95 v2(37.1,53.95)
N30044742: length 1.2
  TOP w0.127: R46.2 39.42,53.95 U35.E3
N30057553: length 1.7
  TOP w0.3: U3.3 93.78,36.5 93.6,36.32 93.6,36.02 93.62,36 U3.4
N30057571: length 1.5
  TOP w0.3: U3.5 R10.2
N30057573: length 1.2
  TOP w0.3: U3.23 R11.2
N30057609: length 1.2
  TOP w0.3: v1(99.31,35.31) 99.12,35.5 U3.14
  vias: v1(92.71,38.1) v1(93.34,38.73) v1(93.98,38.1)
N30058254: length 7.1
  TOP w0.127: v1(62.23,44.45) 62.5,44.18 U14.C2 ; v1(63.52,39.37) 63.14,39.75 U15.B2
  BOTTOM w0.127: v1(62.23,44.45) 62.76,43.92 62.76,41.28 62.97,41.07 62.97,39.92 v1(63.52,39.37)
N30058257: length 7.1
  TOP w0.127: U12.C2 64.75,44.18 v1(64.48,44.45) ; U13.B2 65.39,39.75 v1(65.77,39.37)
  BOTTOM w0.127: v1(64.48,44.45) 65.01,43.92 65.01,41.28 65.22,41.07 65.22,39.92 v1(65.77,39.37)
N30058260: length 7.1
  TOP w0.127: U11.B2 67.64,39.75 v1(68.02,39.37) ; v1(66.73,44.45) 67,44.18 U10.C2
  BOTTOM w0.127: v1(66.73,44.45) 67.26,43.92 67.26,41.28 67.47,41.07 67.47,39.92 v1(68.02,39.37)
N30058263: length 7.1
  TOP w0.127: v1(70.27,39.37) 69.89,39.75 U9.B2 ; v1(68.98,44.45) 69.25,44.18 U8.C2
  BOTTOM w0.127: v1(68.98,44.45) 69.51,43.92 69.51,41.28 69.72,41.07 69.72,39.92 v1(70.27,39.37)
N30058266: length 12.5
  TOP w0.127: Q4.3 73.5,48.7 R42.1 v1(73.5,46.39) ; U7.B2 72.14,39.75 v1(72.52,39.37) ; U6.C2 71.5,44.18 v1(71.23,44.45)
  BOTTOM w0.127: v1(72.52,39.37) 71.97,39.92 71.97,41.07 71.76,41.28 71.76,43.92 v1(71.23,44.45) 73.17,46.39 v1(73.5,46.39)
N30058269: length 16.4
  TOP w0.127: U4.C2 73.75,44.18 v1(73.48,44.45) ; R41.1 78.5,48.7 Q3.3 77.29,48.71 v1(77.24,48.67) ; U5.B2 v1(74.76,39.75)
  BOTTOM w0.127: v1(74.76,39.75) 74.4,40.12 74.4,40.89 74.01,41.28 74.01,43.92 v1(73.48,44.45) 74.58,45.55 74.58,47.78 75.47,48.67 v1(77.24,48.67)
N30061760: length 21
  TOP w0.127: U15.D2 v1(63,38.24) ; v1(55.75,43.1) 55.75,44.34 U17.1 55.75,42.36 55.8,42.3 55.8,42.15 56.05,41.9 56.2,41.9 62.93,35.18 v1(62.93,33.85) ; R116.1 v1(55.1,43.1)
  BOTTOM w0.127: v1(63,38.24) 63,33.92 v1(62.93,33.85) ; v1(55.1,43.1) v1(55.75,43.1)
N30061775: length 21.5
  TOP w0.127: R117.1 v1(55.1,42.35) ; v1(65.28,33.66) 64.93,33.66 56.25,42.33 v1(56.25,42.35) U17.2 ; U13.D2 v1(65.25,38.24)
  BOTTOM w0.127: v1(65.28,33.66) 65.25,33.68 v1(65.25,38.24) ; v1(55.1,42.35) v1(56.25,42.35)
N30061790: length 25.9
  TOP w0.127: v1(67.56,34.16) 64.87,34.16 56.7,42.33 v1(56.7,43.35) 56.7,44.3 U17.3 ; v1(59.35,41.65) 59.8,41.2 R118.1 ; U11.D2 v1(67.5,38.24)
  BOTTOM w0.127: v1(67.5,38.24) 67.5,34.22 v1(67.56,34.16) ; v1(56.7,43.35) 56.7,43.15 56.75,43.1 56.75,42.3 57.4,41.65 v1(59.35,41.65)
N30061799: length 25.2
  TOP w0.127: v1(59.4,42.45) 59.4,42.3 59.8,41.9 R119.1 ; v1(69.72,34.67) 64.77,34.67 57.25,42.19 v1(57.25,42.6) U17.4 ; U9.D2 v1(69.75,38.24)
  BOTTOM w0.127: v1(69.72,34.67) 69.75,34.7 v1(69.75,38.24) ; v1(57.25,42.6) 59.25,42.6 v1(59.4,42.45)
N30061855: length 25.8
  TOP w0.127: U7.D2 v1(72,38.24) ; R120.1 59.95,42.6 59.4,43.15 v1(59.4,43.25) ; U17.5 v1(57.75,43.25) 58.1,42.9 58.1,41.73 64.67,35.16 v1(72.01,35.16)
  BOTTOM w0.127: v1(72.01,35.16) 72,35.16 v1(72,38.24) ; v1(59.4,43.25) v1(57.75,43.25)
N30061867: length 26.3
  TOP w0.127: U5.D2 v1(74.25,38.24) ; R121.1 59.75,43.7 58.68,43.7 58.55,43.57 ; 58.55,43.57 58.55,41.71 64.6,35.66 72.93,35.66 73.15,35.43 v1(74.3,35.43) ; 58.55,43.57 58.25,43.87 U17.6
  BOTTOM w0.127: v1(74.3,35.43) 74.25,35.48 v1(74.25,38.24)
N30061915: length 7.5
  TOP w0.127: U16.6 69,47.84 69.47,47.37 69.98,47.37 70.51,46.84 R18.2 70.75,46.78 72.9,44.63 72.9,44.1 U4.B2
N30061925: length 6.5
  TOP w0.127: U16.5 68.5,47.79 R17.2 69.8,46.78 69.98,46.61 69.98,45.34 70.48,44.83 70.48,44.26 U6.B2
N30061937: length 6.2
  TOP w0.127: U16.4 68,47.29 R16.2 68.79,46.78 68.96,46.61 68.96,45.34 68.45,44.83 68.45,44.05 U8.B2
N30061944: length 6.4
  TOP w0.127: U16.3 R15.2 67.23,46.78 67.01,46.56 67.01,45.29 66.8,45.09 66.42,45.09 66.17,44.83 66.17,44.08 U10.B2
N30061956: length 7.7
  TOP w0.127: U16.2 67,47.29 R14.2 66.21,46.78 66.04,46.61 66.04,45.34 65.76,45.06 64.34,45.06 63.96,44.68 63.96,44.04 U12.B2
N30061963: length 8.8
  TOP w0.127: U14.B2 61.72,44.03 61.72,45.47 63.04,46.78 R13.2 66.5,47.79 U16.1
N30062261: length 28.8
  TOP w0.127: U13.B1 64.41,39.75 v1(64.28,39.88) ; v1(71.03,39.88) 71.16,39.75 U7.B1 ; U15.B1 v1(61.99,39.75) ; U11.B1 66.66,39.75 v1(66.53,39.88) ; U5.B1 73.41,39.75 v1(73.28,39.88) ; R34.2 v1(82.03,41.28) ; v1(68.78,39.88) 68.91,39.75 U9.B1
  TOP w0.23: Q7.6 82.08,42.8 R12.2 R34.2
  PWR_GND w0.3: v1(82.03,41.28) 82.03,40.68 79.6,38.25 75.2,38.25 73.57,39.88 v1(73.28,39.88) 73.16,40 71.85,40 71.73,39.88 v1(71.03,39.88) 70.42,39.88 70.21,40.09 69.19,40.09 68.98,39.88 v1(68.78,39.88) 68.66,40 67.5,40 67.38,39.88 v1(66.53,39.88) 66.41,40 65.25,40 65.13,39.88 v1(64.28,39.88) 63.67,39.88 63.45,40.1 62.35,40.1 62,39.75 v1(61.99,39.75)
N30066642: length 17.4
  TOP w0.127: U34.1 65.06,26.25 64.31,27 R20.2 64.03,26.72 63.88,26.57 63.65,26.57 63.64,26.57 62.7,26.57 62.6,26.47 61.09,26.47 57.79,23.16 57.79,17 U33.B2
N30066644: length 15.4
  TOP w0.127: U31.B2 60.2,16.87 60.2,24.59 61.3,25.69 62.55,25.69 62.62,25.63 63.91,25.63 64.03,25.76 R21.2 64.37,26.13 64.75,25.75 U34.2
N30066646: length 14.4
  TOP w0.127: U29.B2 62.87,17 62.87,18.16 60.73,20.29 60.73,23.39 62.08,24.74 62.62,24.74 62.7,24.82 63.88,24.82 64.03,24.97 R22.2 U34.3
N30066648: length 14
  TOP w0.127: U34.4 64.41,24.75 R23.2 64.03,24.1 63.86,23.93 62.7,23.93 62.68,23.95 62.2,23.95 61.52,23.27 61.52,21.67 65.28,17.91 65.28,16.87 U27.B2
N30066650: length 14
  TOP w0.127: U34.5 64.79,24.25 R24.2 64.03,23.28 63.91,23.15 62.79,23.15 62.44,22.8 62.44,21.51 66.17,17.78 67.56,17.78 67.82,17.53 67.82,16.87 U24.B2
N30066652: length 13.8
  TOP w0.127: U21.B2 70.36,16.87 70.36,17.65 69.8,18.21 66.6,18.21 64.03,20.78 R26.2 64.4,22.62 64.64,22.86 64.64,23.37 65.02,23.75 U34.6
N30067494: length 13.8
  TOP w0.127: U19.B2 72.9,16.87 72.9,17.91 72.14,18.67 67.18,18.67 66.04,19.81 66.04,21.44 65.94,21.53 R28.2 65.62,21.81 66.25,22.44 U34.7
N30068975: length 15.9
  TOP w0.127: U32.B2 75.56,17 75.56,18.42 74.93,19.05 67.41,19.05 66.98,19.48 66.98,21.29 66.73,21.53 R33.2 66.5,21.98 66.75,22.23 U34.8
N30069156: length 17.8
  TOP w0.127: U30.B2 79.5,16.87 79.5,17.53 77.57,19.46 68.68,19.46 68.02,20.12 68.02,21.13 67.62,21.53 R32.2 67.5,22.23 67.75,22.48 U34.10
N30069185: length 19.2
  TOP w0.127: U28.B2 81.92,16.74 81.92,17.53 81.76,17.68 79.98,17.68 77.85,19.81 69.39,19.81 69.04,20.17 69.04,21.31 68.81,21.53 R31.2 68.25,21.79 U34.11
N30069197: length 20.3
  TOP w0.127: U26.B2 84.45,16.74 84.45,17.53 84.05,17.93 80.36,17.93 78.11,20.19 71.63,20.19 70.29,21.53 R30.2 68.75,22.29 U34.12
N30069235: length 22.8
  TOP w0.127: U34.13 70.34,23.75 R29.2 70.97,21.62 72.01,20.57 78.36,20.57 80.75,18.19 86.26,18.19 87.02,17.43 87.02,16.77 U23.B2
N30069271: length 24.8
  TOP w0.127: U20.B2 89.56,16.77 89.56,17.35 89.51,17.4 89.51,17.41 89.37,17.55 87.4,17.55 86.51,18.44 81.05,18.44 78.41,21.08 74.8,21.08 72.39,23.5 71.25,23.5 70.97,23.78 R27.2 70.72,24.25 U34.14
N30069280: length 28
  TOP w0.127: U34.15 70.38,24.75 70.51,24.88 R25.2 70.97,24.61 71.09,24.49 72.42,24.49 72.8,24.1 72.8,23.9 75.24,21.46 78.51,21.46 81.18,18.8 86.54,18.8 87.53,17.81 91.95,17.81 92.2,17.55 92.2,16.87 U18.B2
N30070866: length 37.8
  TOP w0.127: v1(85.53,14.83) 85.78,15.07 U23.C1 ; U22.A1 103.25,36.32 v1(103.52,36.05)
  BOTTOM w0.127: v1(85.53,14.83) 86.9,13.46 92.17,13.46 102.01,23.3 102.01,27.71 100.84,28.88 100.84,34.54 101.85,35.56 103.03,35.56 v1(103.52,36.05)
N30070870: length 36.7
  TOP w0.127: U26.C1 83.24,15.07 v1(82.99,14.83) ; v1(103.52,31.8) 103.25,32.07 U25.A1
  BOTTOM w0.127: v1(103.52,31.8) 103.52,30.47 103.23,30.18 101.75,30.18 101.37,29.79 101.37,29.11 102.39,28.09 102.39,23.14 92.33,13.08 84.74,13.08 v1(82.99,14.83)
N30103916: length 13.7
  TOP w0.127: R72.1 92.71,40 v1(91.97,40.73)
  BOTTOM w0.127: J8.2 90.32,49.11 90.32,46.16 91.97,44.51 v1(91.97,40.73)
N30104433: length 2.9
  TOP w0.127: R72.2 R73.2 94.72,39.47 C46.1 95,39.25 U3.24
N30112835: length 1.1
  TOP w0.3: U36.2 R38.1
N30116209: length 55.1
  TOP w0.127: U17.19 51.9,47.5 51.3,46.9 51.3,43.65 53.55,41.4 55.75,41.4 55.85,41.3 55.92,41.3 61.68,35.54 61.68,33.9 62.79,32.79 62.97,32.79 65.12,30.63 83.75,30.63 84.57,31.46 v1(85.37,31.46) ; v1(85.37,28.48) 85.35,28.5 R51.1 83.75,28 U39.19 ; Q6.3 v1(85.38,31.46)
  BOTTOM w0.127: v1(85.38,31.46) v1(85.37,31.46) v1(85.37,28.48)
N30116224: length 49.8
  TOP w0.127: v1(83.97,29.62) 83.88,29.52 83.88,28.76 83.62,28.5 R50.1 83.25,28.25 U39.20 ; U17.20 51.9,47 51.6,46.7 51.6,43.75 53.65,41.7 55.85,41.7 55.95,41.6 56.04,41.6 62.19,35.46 62.19,33.95 64.67,31.46 Q5.3 83.22,31.46 83.28,31.52 v1(83.85,31.52)
  BOTTOM w0.127: v1(83.85,31.52) 83.97,31.4 v1(83.97,29.62)
N30125838: length 0.9
  TOP w0.127: U2.30 106.76,5.12 R7.1
N30125857: length 0.9
  TOP w0.127: R9.1 108.76,2.66 U2.2
N30126826: length 1.6
  TOP w0.3: R47.1 SW1UI3.2
N30126876: length 9.6
  TOP w0.2: J7.2 17.7,15.09 17.69,15.1 ; 18.09,15.09 18.1,15.09 J7.4 ; J7.6 18.5,15.13 18.39,15.24
  TOP w0.203: J7.14 20.1,14.1 20.09,14.09 20.09,13.45 19.89,13.25 18.71,13.25 18.51,13.45 18.51,14.09 18.5,14.1 J7.6
  TOP w0.381: 7.5,36 J10.1 ; J10.1 7.5,37.82 ; J10.1 6.59,36.91
  TOP w0.5: 8.41,36.91 J10.1
N30126894: length 3.7
  TOP w0.381: J14.1 13.75,37.82 ; J14.1 14.66,36.91 ; J14.1 12.84,36.91 ; J14.1 13.75,36
N30126899: length 7.8
  TOP w0.2: J7.12 19.7,15.13 v1(19.94,15.37)
  TOP w0.5: J15.1 20.84,37.75 R82.2
  PWR_GND w0.381: 20,36 J15.1 ; J15.1 19.09,36.91 ; J15.1 20.91,36.91 ; J15.1 20,37.82
  vias: v1(20.32,20.45)
N30153200: length 52.4
  TOP w0.127: 102.75,34 102.75,34.3 103.25,34.8 104.14,34.8 104.27,34.93 104.27,38.86 v1(104.39,38.99) 105.1,38.28 R110.2 ; U34.17 70.84,25.75 v1(71.75,26.67)
  BOTTOM w0.127: v1(104.39,38.99) 101.95,41.43 98.07,41.43 97.82,41.18 97.82,40.79 97.06,40.03 91.72,40.03 91.21,39.52 91.21,35.33 89.05,33.17 80.67,33.17 77.5,30 75.08,30 v1(71.75,26.67)
N30154037: length 1.8
  TOP w0.127: U17.10 59.64,46.5 60.14,46 R52.1
N30154081: length 1.7
  TOP w0.127: R53.1 60.1,46.75 59.85,47 U17.11
N30154121: length 1.6
  TOP w0.127: R54.1 U17.12
N30154162: length 1.6
  TOP w0.127: U17.13 R55.1
N30154204: length 1.7
  TOP w0.127: U17.14 57.75,49.5 R56.1
N30154247: length 1.8
  TOP w0.127: R57.1 57.25,49.25 U17.15
N30156263: length 1.7
  TOP w0.127: U39.10 82.75,21.75 R58.1
N30156279: length 1.6
  TOP w0.127: U39.11 R59.1
N30156284: length 1.7
  TOP w0.127: R60.1 83.75,21.75 U39.12
N30156311: length 1.6
  TOP w0.127: U39.13 85.25,23.75 R61.1
N30156316: length 1.4
  TOP w0.127: R62.1 85.5,24.25 U39.14
N30156332: length 1.3
  TOP w0.127: U39.15 R63.1
N30156954: length 2.3
  TOP w0.127: R64.1 79,26.75 79.5,26.25 U39.1
N30156970: length 2.2
  TOP w0.127: R65.1 79.12,26 79.38,25.75 U39.2
N30156975: length 2.1
  TOP w0.127: U39.3 R66.1
N30157002: length 2.2
  TOP w0.127: R67.1 79.51,24.5 79.76,24.75 U39.4
N30157007: length 2.3
  TOP w0.127: R68.1 79.38,23.75 79.88,24.25 U39.5
N30157023: length 2.4
  TOP w0.127: U39.6 79.88,23.75 79.13,23 R69.1
N30157147: length 13.1
  TOP w0.127: U39.7 81.25,22.83 v1(80.64,22.23) ; R70.1 v1(72.9,14.39)
  BOTTOM w0.127: v1(72.9,14.39) 72.9,14.99 73.28,15.37 73.79,15.37 v1(80.64,22.23)
N30157152: length 10.2
  TOP w0.127: R71.1 v1(76.22,15.98) ; v1(81.92,22.23) 81.75,22.39 U39.8
  BOTTOM w0.127: v1(81.92,22.23) 76.22,16.54 v1(76.22,15.98)
N30158305: length 2.7
  TOP w0.127: C40.1 99.98,35.02 R74.1 99.8,34.8 99.06,34.8 98.86,35 U3.13
N30158329: length 3.9
  TOP w0.127: C41.1 100.23,32.75 R75.1 99.5,33.25 99.25,33.5 97.86,33.5 97.5,33.86 U3.12
